## boards/shields/amekey_1/Kconfig.defconfig
```kconfig
if SHIELD_AMEKEY_1

config ZMK_KEYBOARD_NAME
    default "amekey-1"

endif # SHIELD_AMEKEY_1
```
